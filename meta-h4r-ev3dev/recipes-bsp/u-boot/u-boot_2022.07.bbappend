FILESEXTRAPATHS:prepend := "${THISDIR}/configs:"

SRC_URI +=  "file://da850_am18xxevm_defconfig;subdir=git/configs/"